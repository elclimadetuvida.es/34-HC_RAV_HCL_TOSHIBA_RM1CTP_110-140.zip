Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: Project Number
Time: 2019-04-23T14:26:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 14:26:07 2019 * Host: DS-SGH416PJCY * Database: C:\Users\AMITSH~1.K\AppData\Local\Temp\{4E386024-28FD-4788-BF9A-A501FC076760}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 14:26:04 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 14:26:05 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 14:26:05 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft

# IfcBuildingElementProxy: RAV-RM1101CTP-E, 34-HC_RAV_HCL_TOSHIBA_RM1CTP_110-140:RAV-RM1101CTP-E:259924
In: Level 1
Type - Material: Colour RGB-250 000 000, Colour- RGB 255 255 255
Pset_ManufacturerTypeInformation - Manufacturer: Toshiba
Pset_BuildingElementProxyCommon - Reference: RAV-RM1101CTP-E; IsExternal: no
